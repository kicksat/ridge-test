<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>GroundStation_GUI</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>433e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_bb_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>(8,3,1,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>62</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_if_gain</value></param>
<param><key>value</key><value>24</value></param>
<param><key>gui_hint</key><value>(7,3,1,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>8</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_rf_gain</value></param>
<param><key>value</key><value>14</value></param>
<param><key>gui_hint</key><value>(6,3,1,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>14</value></param>
<param><key>stop</key><value>14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>tx_button_1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(0,0,1,1)</value></param>
<param><key>label</key><value>"Command 1"</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>tx_button_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(1,0,1,1)</value></param>
<param><key>label</key><value>"Command 2"</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>tx_button_3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(2,0,1,1)</value></param>
<param><key>label</key><value>"Command 3"</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>tx_button_4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(3,0,1,1)</value></param>
<param><key>label</key><value>"Command 4"</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>tx_button_5</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(4,0,1,1)</value></param>
<param><key>label</key><value>"Command 5"</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_if_gain</value></param>
<param><key>value</key><value>47</value></param>
<param><key>gui_hint</key><value>(7,0,1,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>47</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_rf_gain</value></param>
<param><key>value</key><value>14</value></param>
<param><key>gui_hint</key><value>(6,0,1,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>14</value></param>
<param><key>stop</key><value>14</value></param>
</block>
<block>
<key>Command_TX</key>
<param><key>id</key><value>Command_TX_0</value></param>
<param><key>command_select</key><value>0</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>rx_bb_gain</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>rx_if_gain</value></param>
<param><key>gain0</key><value>rx_rf_gain</value></param>
<param><key>args</key><value>hackrf=a06063c825995d5f</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>(0,1,5,5)</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
