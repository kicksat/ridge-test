<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>GroundStation_GUI</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>TxRx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>[2,6,1,1]</value></param>
<param><key>label</key><value>TX</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TxRxSwitch</value></param>
<param><key>value</key><value>TxRx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_spacing</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_trans</value></param>
<param><key>value</key><value>(channel_spacing*0.5)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>command_file</value></param>
<param><key>value</key><value>/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/PingACK!_160ksps_437505kHz_30kOffset_3s.iq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>[0,6,2,5]</value></param>
<param><key>label</key><value>Commands</value></param>
<param><key>labels</key><value>['PingACK!','ArmBW123','FireBW01','FireBW02','FireBW03','FireBW09','SenMode1','SenMode2','SenMode3','SenMode4','SenMode5','RadMode1','RadMode2','RadMode3','SendACC1','SendACC2','SendACC3','RESET!!!']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>['/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/PingACK!_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/ArmBW123_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/FireBW01_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/FireBW02_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/FireBW03_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/FireBW09_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SenMode1_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SenMode2_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SenMode3_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SenMode4_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SenMode5_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/RadMode1_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/RadMode2_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/RadMode3_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SendACC1_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SendACC2_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/SendACC3_160ksps_437505kHz_30kOffset_3s.iq','/home/tane/Documents/RExLab/ridge-test/Commands/TrimmedCommands/RESET!!!_160ksps_437505kHz_30kOffset_3s.iq']</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_rate</value></param>
<param><key>value</key><value>160e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>437.505e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_adj</value></param>
<param><key>value</key><value>-7000</value></param>
<param><key>gui_hint</key><value>[4,6,1,5]</value></param>
<param><key>label</key><value>Frequency Adjust</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10000</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>30e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>2.5e3</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>record_switch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>(17,1,1,1)</value></param>
<param><key>label</key><value>'Record Raw Signal'</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_bb_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>(17,3,1,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>62</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_if_gain</value></param>
<param><key>value</key><value>24</value></param>
<param><key>gui_hint</key><value>(14,3,3,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>8</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_rf_gain</value></param>
<param><key>value</key><value>14</value></param>
<param><key>gui_hint</key><value>(11,3,3,3)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>14</value></param>
<param><key>stop</key><value>14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_samp_rate</value></param>
<param><key>value</key><value>4.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>(samp_rate/data_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>160e3</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>squelch_detect</value></param>
<param><key>block_id</key><value>squelch_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch_level</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>gui_hint</key><value>[3,6,1,5]</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_arm</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>[2,7,1,1]</value></param>
<param><key>label</key><value>Arm</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_if_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>(14,1,3,2)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>47</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_rate</value></param>
<param><key>value</key><value>4.8e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_rf_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(11,1,3,2)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>14</value></param>
<param><key>stop</key><value>14</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>-200</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>squelch_level</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>data_rate/(2*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq_adj</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>TxRxSwitch</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>TxRxSwitch</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0</value></param>
<param><key>const</key><value>tx_arm</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/home/rexlab/ridge-test/GroundStation/Recordings/raw.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>command_file</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/rexlab/ridge-test/Commands/FilteredRecordings/ArmBW123_160ksps_437505kHz_30kOffset_filtered.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>313/2</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,  samp_rate, channel_spacing, channel_trans, firdes.WIN_BLACKMAN, 6.76)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>kiss_hdlc_deframer</key>
<param><key>id</key><value>kiss_hdlc_deframer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>max_length</key><value>10</value></param>
</block>
<block>
<key>kiss_nrzi_decode</key>
<param><key>id</key><value>kiss_nrzi_decode_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>analog_filter_ch0</key><value>1</value></param>
<param><key>cmix_mode_ch0</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>10e6</value></param>
<param><key>calibration_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_filter_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>30</value></param>
<param><key>pa_path_ch0</key><value>1</value></param>
<param><key>pa_path_mini</key><value>1</value></param>
<param><key>analog_filter_ch1</key><value>1</value></param>
<param><key>cmix_mode_ch1</key><value>0</value></param>
<param><key>calibr_bandw_ch1</key><value>10e6</value></param>
<param><key>calibration_ch1</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>digital_filter_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>chip_mode</key><value>1</value></param>
<param><key>serial</key><value>1D42562394D4C1</value></param>
<param><key>device_type</key><value>1</value></param>
<param><key>file_switch</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>freq+freq_offset</value></param>
<param><key>samp_rate</key><value>tx_rate</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>5e6</value></param>
<param><key>analog_filter_ch0</key><value>1</value></param>
<param><key>cmix_mode_ch0</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>10e6</value></param>
<param><key>calibration_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_filter_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>rx_bb_gain</value></param>
<param><key>lna_path_ch0</key><value>2</value></param>
<param><key>lna_path_mini</key><value>3</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>analog_filter_ch1</key><value>1</value></param>
<param><key>cmix_mode_ch1</key><value>0</value></param>
<param><key>calibr_bandw_ch1</key><value>10e6</value></param>
<param><key>calibration_ch1</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>digital_filter_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>chip_mode</key><value>1</value></param>
<param><key>serial</key><value>1D42562394D4C1</value></param>
<param><key>device_type</key><value>1</value></param>
<param><key>file_switch</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>freq+freq_offset</value></param>
<param><key>samp_rate</key><value>rx_samp_rate</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq+freq_offset</value></param>
<param><key>if_gain0</key><value>1</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>"soapy=0,driver=hackrf"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>tx_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>rx_bb_gain</value></param>
<param><key>freq0</key><value>freq+freq_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>rx_if_gain</value></param>
<param><key>gain0</key><value>rx_rf_gain</value></param>
<param><key>args</key><value>"soapy=0,driver=hackrf"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rx_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>freq+freq_offset</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>sig_tabs@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_level</key><value>squelch_level</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>sig_tabs@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>sig_tabs@2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>512</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(file_rate)</value></param>
<param><key>interp</key><value>int(tx_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>int(rx_samp_rate/samp_rate)</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>record</value></param>
<param><key>const</key><value>record_switch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sig_tabs</value></param>
<param><key>gui_hint</key><value>(0,1,10,5)</value></param>
<param><key>label0</key><value>'Raw RX'</value></param>
<param><key>label1</key><value>'Filtered'</value></param>
<param><key>label2</key><value>'Demodulated'</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>squelch_probe</value></param>
<param><key>type</key><value>int</value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>record</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_and_const_xx_0</source_block_id><sink_block_id>squelch_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>blocks_and_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>kiss_nrzi_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>kiss_nrzi_decode_0</source_block_id><sink_block_id>kiss_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>record</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
