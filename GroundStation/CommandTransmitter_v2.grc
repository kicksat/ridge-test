<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CommandTransmitter_v2</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>TX_Command_1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>"Command_1"</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>TX_Command_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>"Command_2"</value></param>
<param><key>pressed</key><value>2</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>TX_Command_3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>"Command_3"</value></param>
<param><key>pressed</key><value>3</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>command_select</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_rate</value></param>
<param><key>value</key><value>160e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>command_select</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/tane/Documents/RExLab/ridge-test/Commands/command1.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/tane/Documents/RExLab/ridge-test/Commands/command2.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1</value></param>
<param><key>file</key><value>/home/tane/Documents/RExLab/ridge-test/Commands/command3.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>file_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>file_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>samples_per_second</key><value>file_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>file_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>file_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
